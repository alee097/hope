# Repository alee097/hope

## KiCad design Lights/Lights.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric
C2: 100nF; C_0805_2012Metric
D1: LED; LED_D5.0mm
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3: 5.1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1: R_Potentiometer; Potentiometer_Vishay_T7-YA_Single_Vertical
U1: LMC6482; DIP-8_W7.62mm

Connections:
+3.3V: C1.1, D1.1 (K), J1.3, R1.1, RV1.1, U1.8 (V+)
/Vout: J1.2, U1.7
GND: C1.2, J1.1, R2.2, RV1.3, U1.4 (V-)
unnamed: C2.1, D1.2 (A), R3.1, U1.2 (-)
unnamed: R1.2, R2.1, U1.3 (+)
unnamed: C2.2, R3.2, U1.1, U1.5 (+)
unnamed: RV1.2, U1.6 (-)

Board: 2 copper layers, 21.6 x 30.5 mm, 9 parts (0 on the bottom side), 7 nets.

## Commit log

2026-01-30 LIghts Schematic Lab
    1/29
2026-02-06 Light Layout Lab
    Assigned footprints + finished layout and routing
2026-02-20 USB Charger Layout Lab
